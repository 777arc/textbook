options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: rds_rx
    output_language: python
    title: Stereo FM receiver and RDS Decoder
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '8'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0,1, 1
    label: Frequency
    start: '77'
    step: '0.1'
    stop: '108'
    value: '95.5'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: freq_tune
  id: variable
  parameters:
    value: freq*1e6 - freq_offset
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2, 0,1, 1
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49.6'
    value: '25'
  states: {}
- name: pilot_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '19020'
    low_cutoff_freq: '18980'
    samp_rate: '240000'
    type: complex_band_pass
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '1.0'
    gain: '1.0'
    ntaps: '151'
    samp_rate: '19000'
    sym_rate: 19000/8
  states: {}
- name: rrc_taps_manchester
  id: variable
  parameters:
    value: '[rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1, 0,1, 1
    label: Volume
    start: '-20'
    step: '1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '53'
    max_gain: '1000'
    rate: '2e-3'
    reference: '0.585'
    type: complex
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {state: disabled}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    samp_rate: '48000'
    tau: '75e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * math.pi * 19020 / 240000
    min_freq: 2 * math.pi * 18980 / 240000
    w: '0.001'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate / decimation) / (2*math.pi*75000)
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '57000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate/8
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: (len(pilot_taps) - 1) // 2
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/marc/Downloads/fm_clip_for_rds.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/marc/Downloads/test.iq
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: /home/marc/Downloads/working_bytes.uint8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/marc/Downloads/fm_clip_for_rds.iq
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/marc/Downloads/fm_rds_250k_from_sdrplay.iq
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '1000000'
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(1.*(volume)/10)
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.5'
    gain_omega: '0.00'
    mu: '0.01'
    omega: '16'
    omega_relative_limit: '0.00'
    type: complex
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: digital.constellation_bpsk().base()
    fmax: '0.002'
    fmin: '-0.002'
    loop_bw: 2*math.pi / 100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '1.0'
    ted_type: digital.TED_ZERO_CROSSING
    type: cc
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '16'
    ted_gain: '5'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Quadrature Demod Python',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              output_items[0][0:-1] = 0.5 * np.angle(input_items[0][0:-1] * np.conj(input_items[0][1:])) # see https://wiki.gnuradio.org/index.php/Quadrature_Demod
              return len(output_items[0] - 1)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.filter import firdes
      from scipy.signal import lfilter

      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='Freq Shift and Filter',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.complex64],
                  decim=10 # like original block
              )
              self.set_relative_rate(1.0/10)
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).


          def work(self, input_items, output_items):
              N = len(input_items[0])
              if N >= 1000:
                  N = 1000 # still not sure why but this fixes it
                  samp_rate = 250e3 # sample rate of file
                  f_o = -57e3
                  t = np.arange(N)/samp_rate

                  # Try band pass filtering before shift
                  #taps = firdes.complex_band_pass(1.0, samp_rate, f_o - 7.5e3, f_o + 7.5e3, 5e3) # same as original flowgraph
                  #out = np.convolve(input_items[0], taps, 'same') # low pass filter
                  out = input_items[0][0:N]

                  out = out * np.exp(2j*np.pi*f_o*t) # SHOULDNT MATTER WHICH DIRECTION BECAUSE INPUT SIGNAL IS REAL OR BECAUSE RDS IS REDUNDANT
                  
                  
                  
                  taps = firdes.low_pass(1.0, samp_rate, 7.5e3, 5e3) # same as original flowgraph
                  out = np.convolve(out, taps, 'same') # low pass filter
                  #out = lfilter(taps, [1.0], out) # looks same as convolve when using 'same'
                  out = out[::10] # decimate
                  out = out.astype(np.complex64) # not actually needed
                  output_items[0][0:len(out)] = out

                  return len(out)
              else:
                  return 0
                  
          # NOTE I GOT THIS TO WORK BUT ITS NOT DECODING AS WELL AS THE ORIGINAL!  AND THE NEGATIVE SIGN IN EXP DIDNT MAKE A DIFFERENCE!
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from scipy.signal import resample_poly

      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='Rational Resampler Python',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )


          def general_work(self, input_items, output_items):
              """example: multiply with constant"""
              if len(input_items[0]) > 2000: # just to be safe
                  out = resample_poly(input_items[0], 19, 25) # goes from the current 25k to 19k
                  output_items[0][0:len(out)] = out
                  self.consume(0, len(input_items[0])) # consume all on the input port
                  return len(out) # tell it how many outputs we made
              else:
                  return 0
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      from gnuradio.filter import firdes

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='manchester',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              rrc_taps = firdes.root_raised_cosine(1, 19e3, 19e3/8, 1, 151) # gain, samp_rate, symbol_rate, alpha, n_taps
              self.taps = [rrc_taps[n] - rrc_taps[n+8] for n in range(len(rrc_taps)-8)]

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              if len(input_items[0]) > 1000:
                  output_items[0][:] = np.convolve(input_items[0], self.taps, 'same')
                  return len(output_items[0])
              else:
                  return 0
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n# Constants\nsyndrome = [383, 14, 303, 663, 748]\noffset_pos = [0, 1, 2, 3, 2]\noffset_word = [252, 408, 360, 436, 848]\n\n# see Annex B, page 64 of the standard\ndef calc_syndrome(message, mlen):\n    reg = 0\n    poly = 0x5B9 # const unsigned long \n    plen = 10 # const unsigned char \n    \n    for i in range(mlen, 0, -1):\n        reg = (reg << 1) | ((message >> (i-1)) & 0x01)\n        if (reg & (1 << plen)):\n            reg = reg ^ poly\n    \n    for i in range(plen, 0, -1):\n        reg = reg << 1\n        if (reg & (1 << plen)):\n            reg = reg ^ poly\n    return reg & ((1 << plen) - 1) # select the bottom plen bits of reg\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='RDS Decoder Python',   # will show up in GRC\n            in_sig=[np.uint8],\n            out_sig=None\n        )\n        self.synced = False\n        self.presync = False\n        self.wrong_blocks_counter = 0\n        self.blocks_counter = 0\n        self.group_good_blocks_counter = 0\n        self.block_number = 0\n        self.group_assembly_started = False\n        self.block_bit_counter = 0\n        self.reg = np.uint32(0) # was unsigned long in C++ (64 bits) but numpy doesnt support bitwise ops of uint64\n        self.bit_counter = 0\n        self.offset_chars = ['z','z','z','z'] # 4 chars, need to be separated because strings are not mutable\n        self.lastseen_offset_counter = 0\n        self.lastseen_offset = 0\n        self.group = [0,0,0,0]\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n\n    def work(self, input_items, output_items):\n        noutput_items = len(input_items[0])\n        \n        if noutput_items < 104: # process 104 at a time, 1 msg output\n            return 0\n        \n        # Just process 1 msg at a time\n        noutput_items = 104\n    \n        # the synchronization process is described in Annex C, page 66 of the standard */\n        i = 0\n        while (i < noutput_items):\n            # in C++ reg doesn't get init so it will be random at first, for ours its 0s\n            # It was also an unsigned long but never seemed to get anywhere near the max value\n            # input_items are either 0 or 1\n            self.reg = np.bitwise_or(np.left_shift(self.reg, 1), input_items[0][i]) # reg contains the last 26 rds bits. these are both bitwise ops\n            #print('reg: ', self.reg)\n            if not self.synced:\n                reg_syndrome = calc_syndrome(self.reg, 26)\n                for j in range(5):\n                    if reg_syndrome == syndrome[j]:\n                        if not self.presync:\n                            self.lastseen_offset = j\n                            self.lastseen_offset_counter = self.bit_counter\n                            self.presync = True\n                        else:\n                            bit_distance=self.bit_counter - self.lastseen_offset_counter\n                            if offset_pos[self.lastseen_offset] >= offset_pos[j]:\n                                block_distance = offset_pos[j] + 4 - offset_pos[self.lastseen_offset]\n                            else:\n                                block_distance = offset_pos[j] - offset_pos[self.lastseen_offset]\n                            if (block_distance*26) != bit_distance:\n                                self.presync = False\n                            else:\n                                print('Sync State Detected')\n                                self.wrong_blocks_counter = 0\n                                self.blocks_counter = 0\n                                self.block_bit_counter = 0\n                                self.block_number = (j + 1) % 4\n                                self.group_assembly_started = False\n                                self.synced = True\n                    break #syndrome found, no more cycles\n\n            else: # SYNCED\n                # wait until 26 bits enter the buffer */\n                if self.block_bit_counter < 25:\n                    self.block_bit_counter += 1\n                else:\n                    good_block = False\n                    dataword = (self.reg >> 10) & 0xffff\n                    block_calculated_crc = calc_syndrome(dataword, 16)\n                    checkword = self.reg & 0x3ff\n                    # manage special case of C or C' offset word */\n                    if (self.block_number==2):\n                        block_received_crc=checkword^offset_word[self.block_number]\n                        if (block_received_crc==block_calculated_crc):\n                            good_block = True\n                            offset_char = 'C'\n                        else:\n                            block_received_crc=checkword ^ offset_word[4]\n                            if (block_received_crc==block_calculated_crc):\n                                good_block = True\n                                offset_char = 'c'  # C' (C-Tag)\n                            else:\n                                self.wrong_blocks_counter += 1\n                                good_block = False\n                    else:\n                        block_received_crc = checkword ^ offset_word[self.block_number] # bitwise xor\n                        if block_received_crc == block_calculated_crc:\n                            good_block = True\n                            if (self.block_number==0):\n                                offset_char = 'A'\n                            elif (self.block_number==1):\n                                offset_char = 'B'\n                            elif (self.block_number==3):\n                                offset_char = 'D'\n                        else:\n                            self.wrong_blocks_counter += 1\n                            good_block = False\n                        \n                    # done checking CRC */\n                    if self.block_number == 0 and good_block:\n                        self.group_assembly_started = True\n                        self.group_good_blocks_counter = 1\n                        \n                    if self.group_assembly_started:\n                        if not good_block:\n                            self.group_assembly_started = False\n                        else:\n                            self.group[self.block_number] = dataword\n                            self.offset_chars[self.block_number] = offset_char\n                            self.group_good_blocks_counter += 1\n                            print('group_good_blocks_counter:', self.group_good_blocks_counter)\n                        if self.group_good_blocks_counter == 5:\n                            # raw data bytes, as received from RDS. 8 info bytes, followed by 4 RDS offset chars: ABCD/ABcD/EEEE (in US)\n                            bytes = bytearray(12) # 12 bytes filled with 0s\n\n                            # RDS information words\n                            bytes[0] = (self.group[0] >> 8) & 255\n                            bytes[1] = (self.group[0]     ) & 255\n                            bytes[2] = (self.group[1] >> 8) & 255\n                            bytes[3] = (self.group[1]     ) & 255\n                            bytes[4] = (self.group[2] >> 8) & 255\n                            bytes[5] = (self.group[2]     ) & 255\n                            bytes[6] = (self.group[3] >> 8) & 255\n                            bytes[7] = (self.group[3]     ) & 255\n\n                            # RDS offset words\n                            bytes[8] = self.offset_chars[0].encode()[0]\n                            bytes[9] = self.offset_chars[1].encode()[0]\n                            bytes[10] = self.offset_chars[2].encode()[0]\n                            bytes[11] = self.offset_chars[3].encode()[0]\n                        \n                            print(bytes)\n                            \n                            #data = pmt.make_blob(bytes, 12)\n                            #meta = pmt.PMT_NIL\n                            #pdu = pmt.cons(meta, data) # make PDU: (metadata, data) pair\n                            #self.message_port_pub(pmt.intern('msg_out'), pdu)\n\n                    self.block_bit_counter = 0\n                    self.block_number = (self.block_number + 1) % 4\n                    self.blocks_counter += 1\n                    # 1187.5 bps / 104 bits = 11.4 groups/sec, or 45.7 blocks/sec */\n                    if self.blocks_counter == 50:\n                        if self.wrong_blocks_counter > 35:\n                            print(\"@@@@@ Lost Sync (Got \", self.wrong_blocks_counter, \" bad blocks on \", self.blocks_counter, \" total)\")\n                            self.synced = False\n                            self.presync = False\n                        else:\n                            print(\"@@@@@ Still Sync-ed (Got \", self.wrong_blocks_counter, \" bad blocks on \", self.blocks_counter, \" total)\")\n                        self.blocks_counter = 0\n                        self.wrong_blocks_counter = 0\n            i += 1\n            self.bit_counter += 1\n      \n\n    \n        return noutput_items\n\n"
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nrds_group_acronyms = [\"BASIC\", \"PIN/SL\", \"RT\", \"AID\", \"CT\", \"TDC\", \"IH\", \"RP\", \"TMC\", \"EWS\", \"___\", \"___\", \"___\", \"___\", \"EON\", \"___\"]\n    \n# Annex F of RBDS Standard Table F.1 (North America) and Table F.2 (Europe)\npty_table = [[\"Undefined\",             \"Undefined\"],\n             [\"News\",                  \"News\"],\n             [\"Current Affairs\",       \"Information\"],\n             [\"Information\",           \"Sports\"],\n             [\"Sport\",                 \"Talk\"],\n             [\"Education\",             \"Rock\"],\n             [\"Drama\",                 \"Classic Rock\"],\n             [\"Culture\",               \"Adult Hits\"],\n             [\"Science\",               \"Soft Rock\"],\n             [\"Varied\",                \"Top 40\"],\n             [\"Pop Music\",             \"Country\"],\n             [\"Rock Music\",            \"Oldies\"],\n             [\"Easy Listening\",        \"Soft\"],\n             [\"Light Classical\",       \"Nostalgia\"],\n             [\"Serious Classical\",     \"Jazz\"],\n             [\"Other Music\",           \"Classical\"],\n             [\"Weather\",               \"Rhythm & Blues\"],\n             [\"Finance\",               \"Soft Rhythm & Blues\"],\n             [\"Children’s Programmes\", \"Language\"],\n             [\"Social Affairs\",        \"Religious Music\"],\n             [\"Religion\",              \"Religious Talk\"],\n             [\"Phone-In\",              \"Personality\"],\n             [\"Travel\",                \"Public\"],\n             [\"Leisure\",               \"College\"],\n             [\"Jazz Music\",            \"Spanish Talk\"],\n             [\"Country Music\",          \"Spanish Music\"],\n             [\"National Music\",        \"Hip Hop\"],\n             [\"Oldies Music\",          \"Unassigned\"],\n             [\"Folk Music\",            \"Unassigned\"],\n             [\"Documentary\",           \"Weather\"],\n             [\"Alarm Test\",            \"Emergency Test\"],\n             [\"Alarm\",                 \"Emergency\"]]\npty_locale = 1 # set to 0 for europe\n\n\n# page 72, Annex D, table D.2 in the standard\ncoverage_area_codes = [\"Local\",\n                       \"International\",\n                       \"National\",\n                       \"Supra-regional\",\n                       \"Regional 1\",\n                       \"Regional 2\",\n                       \"Regional 3\",\n                       \"Regional 4\",\n                       \"Regional 5\",\n                       \"Regional 6\",\n                       \"Regional 7\",\n                       \"Regional 8\",\n                       \"Regional 9\",\n                       \"Regional 10\",\n                       \"Regional 11\",\n                       \"Regional 12\"]\n    \n\n# page 71, Annex D, table D.1 in the standard, or http://poupa.cz/rds/countrycodes.htm\npi_country_codes = [[\"DE\",\"GR\",\"MA\",\"__\",\"MD\"],\n                    [\"DZ\",\"CY\",\"CZ\",\"IE\",\"EE\"],\n                    [\"AD\",\"SM\",\"PL\",\"TR\",\"__\"],\n                    [\"IL\",\"CH\",\"VA\",\"MK\",\"__\"],\n                    [\"IT\",\"JO\",\"SK\",\"__\",\"__\"],\n                    [\"BE\",\"FI\",\"SY\",\"__\",\"UA\"],\n                    [\"RU\",\"LU\",\"TN\",\"__\",\"__\"],\n                    [\"PS\",\"BG\",\"__\",\"NL\",\"PT\"],\n                    [\"AL\",\"DK\",\"LI\",\"LV\",\"SI\"],\n                    [\"AT\",\"GI\",\"IS\",\"LB\",\"__\"],\n                    [\"HU\",\"IQ\",\"MC\",\"__\",\"__\"],\n                    [\"MT\",\"GB\",\"LT\",\"HR\",\"__\"],\n                    [\"DE\",\"LY\",\"YU\",\"__\",\"__\"],\n                    [\"__\",\"RO\",\"ES\",\"SE\",\"__\"],\n                    [\"EG\",\"FR\",\"NO\",\"BY\",\"BA\"]]\n    \n\n\n\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='RDS Parser Python',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n\n        self.radiotext_AB_flag = 0\n        self.radiotext = [' ']*65\n        \n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n\n    # The only type we will bother decoding, it's the radiotext that shows up on the screen\n    def decode_type2(self, group_1, group_2, group_3, ab):\n        text_segment_address_code = group_1 & 0x0f\n\n        # when the A/B flag is toggled, flush your current radiotext\n        if self.radiotext_AB_flag != ((group_1 >> 4) & 0x01):\n            self.radiotext = [' ']*65\n\n        self.radiotext_AB_flag = (group_1 >> 4) & 0x01\n\n        if not ab:\n            self.radiotext[text_segment_address_code *4     ] = chr((group_2 >> 8) & 0xff)\n            self.radiotext[text_segment_address_code * 4 + 1] = chr(group_2        & 0xff)\n            self.radiotext[text_segment_address_code * 4 + 2] = chr((group_3 >> 8) & 0xff)\n            self.radiotext[text_segment_address_code * 4 + 3] = chr(group_3        & 0xff)\n        else:\n            self.radiotext[text_segment_address_code * 2    ] = chr((group_3 >> 8) & 0xff)\n            self.radiotext[text_segment_address_code * 2 + 1] = chr(group_3        & 0xff)\n\n        print(\"====radiotext====\", ''.join(self.radiotext))\n        \n        return\n    \n    def handle_msg(self, msg):\n        bytes = pmt.to_python(pmt.cdr(msg)) # np array of uint8's/chars, always len 12, 8 data + 4 offset chars, either \"ABCD\", \"ABcD\", \"EEEE\" (in US)\n        \n        group_0 = bytes[1] | (bytes[0] << 8)\n        group_1 = bytes[3] | (bytes[2] << 8)\n        group_2 = bytes[5] | (bytes[4] << 8)\n        group_3 = bytes[7] | (bytes[6] << 8)\n          \n        group_type = (group_1 >> 12) & 0xf\n        ab = (group_1 >> 11 ) & 0x1 # b if 1, a if 0\n\n        \n        print(\"group_type:\", group_type) # this is essentially message type, i only see type 0 and 2 in my recording\n        print(\"ab:\", ab)\n        print(\"rds_group_acronym:\", rds_group_acronyms[group_type])\n\n        program_identification = group_0     # \"PI\"\n        \n        program_type = (group_1 >> 5) & 0x1f # \"PTY\"\n        pty = pty_table[program_type][pty_locale]\n        \n        pi_country_identification = (program_identification >> 12) & 0xf\n        \n        pi_area_coverage = (program_identification >> 8) & 0xf\n        coverage_area = coverage_area_codes[pi_area_coverage]\n        \n        pi_program_reference_number = program_identification & 0xff # just an int\n        \n        \n        \n        print(\"PTY:\", pty)\n        print(\"program:\", pi_program_reference_number)\n        print(\"coverage_area:\", coverage_area)\n\n        # I dont understand this part, US isnt on the list\n        print(\"country:\")\n        print(pi_country_codes[pi_country_identification - 1][0], end='')\n        print(pi_country_codes[pi_country_identification - 1][1], end='')\n        print(pi_country_codes[pi_country_identification - 1][2], end='')\n        print(pi_country_codes[pi_country_identification - 1][3], end='')\n        print(pi_country_codes[pi_country_identification - 1][4])\n\n        if group_type == 2:\n            self.decode_type2(group_1, group_2, group_3, ab)\n        else:\n            print(\"unsupported group_type\")\n\n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n        \n"
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pilot_taps
    type: fcc
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(1.0,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_1_0
  id: fir_filter_xxx
  parameters:
    decim: '5'
    taps: firdes.low_pass(-2.1,240000,15e3,2e3)
    type: fff
  states: {}
- name: fir_filter_xxx_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps_manchester
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 100000, 20000)
    type: ccc
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 57e3
    decim: '10'
    samp_rate: samp_rate / decimation
    taps: firdes.low_pass(1.0, samp_rate / decimation, 7.5e3, 5e3)
    type: fcf
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 7.5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/8
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: note_0
  id: note
  parameters:
    note: L+R
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    size: '200'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    int_max: '0'
    int_min: '-80'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation
    interp: '240000'
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate // decimation // 10
    interp: '19000'
    type: ccc
  states: {state: disabled}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    debug: 'True'
    pty_locale: '1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq_tune
    gain0: '70'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', blocks_file_sink_1, '0']
- [analog_agc_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '0']
- [analog_pll_refout_cc_0, '0', blocks_multiply_xx_0, '1']
- [analog_quadrature_demod_cf_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_2, '1']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '0']
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_file_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_file_source_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_file_source_0_0, '0', epy_block_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_2, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_imag_0, '0']
- [blocks_multiply_xx_1, '0', fir_filter_xxx_1_0, '0']
- [blocks_multiply_xx_2, '0', low_pass_filter_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_file_sink_2, '0']
- [digital_diff_decoder_bb_0, '0', epy_block_4, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', blocks_float_to_complex_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', freq_xlating_fir_filter_xxx_1_0, '0']
- [epy_block_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1, '0', rational_resampler_xxx_1, '0']
- [epy_block_2, '0', epy_block_3, '0']
- [epy_block_2, '0', fir_filter_xxx_2, '0']
- [epy_block_3, '0', analog_agc_xx_0, '0']
- [epy_block_3, '0', digital_clock_recovery_mm_xx_0, '0']
- [epy_block_3, '0', digital_symbol_sync_xx_0, '0']
- [epy_block_4, msg_out, rds_parser_0, in]
- [fir_filter_xxx_0, '0', analog_pll_refout_cc_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_1_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_2, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_head_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', epy_block_2, '0']
- [freq_xlating_fir_filter_xxx_1_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', blocks_keep_one_in_n_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_1, '0', fir_filter_xxx_2, '0']
- [rds_decoder_0, out, blocks_message_debug_0, print]
- [rds_decoder_0, out, epy_block_5, msg_in]
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
